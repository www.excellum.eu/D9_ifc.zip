Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-12-23T12:34:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161117_1200(x64) - Exporter 17.0.1099.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 23 12:34:04 2016 * Host: WITAS2 * Database: C:\Users\WITAS_~1\AppData\Local\Temp\{9A9F9826-5FC3-4164-B656-056E5A4E2FA4}\ifc * Database version: 5507 * Database creation date: Fri Dec 23 12:34:04 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 23 12:34:04 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 23 12:34:04 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: D93 LEDW30SX1, Dummy:D93 LEDW30SX1:209086
In: Level 1
Type - Material: BE Glas, BE Kader, BE_G Glas lamp, BE Armatuur
Type - Constraints - Default Elevation: 1000 mm; WT_H Behuizing: Standaard; WT_H Breedte: 190 mm; WT_H Coarse geometrie: Standaard; WT_H Halve breedte negatief: -95 mm; WT_H Halve lengte negatief: -95 mm; WT_H Hoogte: 87 mm; WT_H Inbouw: yes; WT_H Inbouwdiepte: 83 mm; WT_H Lengte: 190 mm; WT_H Optie: IP44; WT_H Referentie: Inbouw; WT_H Symbool plafond_stral: 95 mm; WT_H Symbool wand hoogte: 87 mm; WT_H Symbool wand lengte: 190 mm; WT_H Uitsnijding_diameter: 175 mm; WT_H Uitsteek: 0 mm
Type - Dimensions - BE_G Breedte: 0 mm; BE_G Diameter: 190 mm; BE_G Hoogte: 87 mm; BE_G Lengte: 0 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 292 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 292 W
Type - Graphics - WT_V Symbool plafond: round - luminaire - led; WT_V Symbool wand: none_gen
Type - Identity Data - BE_I Bestelcode: D93/LEDW30SX1; Manufacturer: ETAP; Model: D9 led; Type Name: D93 LEDW30SX1; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - WT_V Materiaal armatuur: BE Armatuur; WT_V Materiaal kader: BE Kader
Type - Model Properties - WT_I Armatuurrendement: 0; WT_I Dimbaar: Nee; WT_I IP klasse: IP20; WT_I Kleur: wit; WT_I Lampkleur: 4000K; WT_I Lichtstroom armatuur: 2950 lm; WT_I Maatschets catalogus: -; WT_I Maximale temperatuur: 850°C; WT_I Montage: Inbouw; WT_I Optiek: downlight - breedstralend; WT_I UGR: <=25; WT_I Uitsnijding: 175; WT_I Voorschakelapparaat: S; WT_I Vorm: downlight
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP D9 - lichtbron: NO IES; WT_I Aantal lampen: 1; WT_I Afschermhoek: 0 deg; WT_I Lamptype: LED MODULE; WT_I Luminantie: 0; WT_I Vermogen lamp: 292 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: D93 LEDW30SX1
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.260549 m2; Volume: 0.0109832 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-292 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 23
Other - Family: Dummy: D93 LEDW30SX1; Family and Type: Dummy: D93 LEDW30SX1; Schedule Level: Level: Level 1; Type: Dummy: D93 LEDW30SX1; Type Id: Dummy: D93 LEDW30SX1
Phasing - Phase Created: 64113
